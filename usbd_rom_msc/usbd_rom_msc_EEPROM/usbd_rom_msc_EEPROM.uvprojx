# Keil uVision project usbd_rom_msc_EEPROM.uvprojx, settings and files
target usbd_rom_msc_EEPROM (6160000::V6.16::ARMCLANG)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x02000000,0x9000) CPUTYPE("Cortex-M3") CLOCK(75000000) ELITTLE
  output: usbd_rom_msc_EEPROM
  c flags: Optim=5 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CORE_M3,RTE_BOARD_SUPPORT_LPCOPEN
  c include: .\inc;..\..\..\libs\lib_lpc_chip_15xx\inc;..\..\..\libs\lib_nxp_lpcxpresso_1549_board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group inc
    ./inc/: app_usbd_cfg.h msc_usb.h
  group src
    ./src/: msc_desc.c msc_main.c msc_user.c
  group libs
    ../../../libs/lib_lpc_chip_15xx/Objects/: lib_lpc_chip_15xx.lib
    ../../../libs/lib_nxp_lpcxpresso_1549_board/Objects/: lib_nxp_lpcxpresso_1549_board.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 2.20
