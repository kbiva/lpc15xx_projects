# Keil uVision project LPCXpresso1549_blinky_tneo.uvprojx, settings and files
target LPCXpresso1549_blinky_tneo (6160000::V6.16::ARMCLANG)
  device: LPC1549JBD64 NXP
  pack: Keil.LPC1500_DFP.1.2.1
  cpu: IRAM(0x02000000,0x9000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LPCXpresso1549_blinky_tneo
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: CORE_M3,RTE_BOARD_SUPPORT_LPCOPEN
  c include: ..\..\libs\lib_lpc_chip_15xx\inc;..\..\libs\lib_TNeo\src;..\..\libs\lib_nxp_lpcxpresso_1549_board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
  group src
    ./src/: main.c tn_app_check.c
  group libs
    ../../libs/lib_TNeo/Objects/: lib_TNeo.lib
    ../../libs/lib_lpc_chip_15xx/Objects/: lib_lpc_chip_15xx.lib
    ../../libs/lib_nxp_lpcxpresso_1549_board/Objects/: lib_nxp_lpcxpresso_1549_board.lib
software components: CMSIS:CORE 5.5.0, Device:Startup 2.20
